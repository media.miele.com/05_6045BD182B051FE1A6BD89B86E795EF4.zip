Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 48ce933e-8530-4c45-bd3b-392e5471dd6f, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-12T10:23:43+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12534190_CH_DAH1950_OBSW:28H1950B_CH_12534190_DAH1950_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_CLST, <Unnamed>, z_Miele_Design_OBSW, z_Miele_Design_Glass, z_Miele_Design_Steel_Chrom, z_Miele_Connection_Connection_Modul
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 898 mm; Height: 443 mm; Depth: 388 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 28H1950B_CH_12534190_DAH1950_OBSW; sets with these values: 2
